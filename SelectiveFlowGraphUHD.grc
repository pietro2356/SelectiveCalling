options:
  parameters:
    author: pietro
    generate_options: qt_gui
    id: SelectiveFlowGraphUHD
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: band
  id: variable_qtgui_chooser
  parameters:
    label: Band
    label0: NB PMR 12.5k
    label1: NB VHF 12k
    label2: WB FM
    num_opts: '3'
    option0: int(25e2)
    option1: int(5e2)
    option2: int(38e3)
    type: int
    value: int(25e2)
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: '161812500'
  states: {}
- name: freq_ch
  id: variable_qtgui_chooser
  parameters:
    label: Frequency
    label0: URG TN
    label1: 118 ELI
    label2: PRM CH4 SEL
    label3: FM RADIO
    num_opts: '4'
    option0: '161812500'
    option1: '161862500'
    option2: '446043750'
    option3: int(99300000)
    type: int
    value: '161812500'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squelch
    start: '-150'
    step: '1'
    stop: '20'
    value: '-50'
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0.1'
    step: '0.1'
    stop: '2'
    value: '1'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '50000'
    max_dev: band
    quad_rate: quadrature
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38e2
    low_cutoff_freq: '300'
    samp_rate: audio_samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    ctrlpanel: 'True'
    fc: freq_ch
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_samp_rate
    fc: freq_ch
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq_ch
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: selcal_selcall_decoder_0
  id: selcal_selcall_decoder
  parameters:
    code_length: '5'
    debug: 'False'
    protocol: CCIR-1
    sample_rate: audio_samp_rate
    target_code: '11501'
    tone_duration_ms: '0.0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_nbfm_rx_0, '0']
- [band_pass_filter_0, '0', selcal_selcall_decoder_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', band_pass_filter_0, '0']
- [selcal_selcall_decoder_0, '0', audio_sink_0, '0']
- [selcal_selcall_decoder_0, selcall_out, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
