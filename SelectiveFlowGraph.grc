options:
  parameters:
    author: pietro
    generate_options: qt_gui
    id: SelectiveFlowGraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 38e2
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pietro/Projects/UniTN/NextGenerationNetwork/SDR/SelectiveCalling/selettive_audio/50545-76845-AUD.wav
    repeat: 'False'
  states: {}
- name: bomboklat_mimibombo_0
  id: bomboklat_mimibombo
  parameters:
    gain: '2'
  states: {}
- name: selcal_selcall_decoder_0
  id: selcal_selcall_decoder
  parameters:
    code_length: '5'
    debug: 'False'
    protocol: ZVEI-2
    sample_rate: samp_rate
    target_code: '76845'
    tone_duration_ms: '0.0'
  states: {}

connections:
- [band_pass_filter_0, '0', selcal_selcall_decoder_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [bomboklat_mimibombo_0, '0', audio_sink_0, '0']
- [selcal_selcall_decoder_0, '0', bomboklat_mimibombo_0, '0']
- [selcal_selcall_decoder_0, selcall_out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
